# IAR project CppUTest_UnitTest.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F564ML R5F564ML
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x600
  General.IStackSize: 0x600
  General.HeapSize: 0x8000
  ICCRX.CCDefines: CPPUTEST_USE_STD_CPP_LIB=0; CPPUTEST_MEM_LEAK_DETECTION_DISABLED=1; std
  ICCRX.CCIncludePath2: _release\include
  ICCRX.IccLang: 2
  OBJCOPY.OOCOutputFile: CppUTest_UnitTest.srec
  ILINK.IlinkOutputFile: CppUTest_UnitTest.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  ICCRX.IccLang: 0
  group (top)
    ../../tests/: AllocationInCFile.c AllocationInCFile.h AllocationInCppFile.cpp AllocationInCppFile.h AllocLetTestFree.c AllocLetTestFree.h AllocLetTestFreeTest.cpp AllTests.cpp AllTests.h CheatSheetTest.cpp CommandLineArgumentsTest.cpp CommandLineTestRunnerTest.cpp JUnitOutputTest.cpp MemoryLeakDetectorTest.cpp MemoryLeakWarningTest.cpp MemoryOperatorOverloadTest.cpp PluginTest.cpp PreprocessorTest.cpp RunAllTests.sh SetPluginTest.cpp SimpleMutexTest.cpp SimpleStringTest.cpp TeamCityOutputTest.cpp TestFailureNaNTest.cpp TestFailureTest.cpp TestFilterTest.cpp TestHarness_cTest.cpp TestHarness_cTestCFile.c TestInstallerTest.cpp TestMemoryAllocatorTest.cpp TestOutputTest.cpp TestRegistryTest.cpp TestResultTest.cpp TestUTestMacro.cpp TestUTestStringMacro.cpp UtestPlatformTest.cpp UtestTest.cpp
    _release/: CppUTest.a
