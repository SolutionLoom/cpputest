# IAR project CppUTest.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F564ML R5F564ML
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: CPPUTEST_USE_STD_CPP_LIB=0; CPPUTEST_MEM_LEAK_DETECTION_DISABLED=1; std
  ICCRX.CCIncludePath2: _debug\include
  ICCRX.IccLang: 1
  OBJCOPY.OOCOutputFile: CppUTest.srec
  prebuild: ruby ..\..\scripts\CopyIncludes.rb  "_debug\include"
  ILINK.IlinkOutputFile: CppUTest.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  ICCRX.IccLang: 0
  group (top)
    ../../src/CppUTest/: CommandLineArguments.cpp CommandLineTestRunner.cpp JUnitTestOutput.cpp MemoryLeakDetector.cpp MemoryLeakWarningPlugin.cpp SimpleMutex.cpp SimpleString.cpp TeamCityTestOutput.cpp TestFailure.cpp TestFilter.cpp TestHarness_c.cpp TestMemoryAllocator.cpp TestOutput.cpp TestPlugin.cpp TestRegistry.cpp TestResult.cpp TestTestingFixture.cpp Utest.cpp
    ../../src/Platforms/Iar/: UtestPlatform.cpp
